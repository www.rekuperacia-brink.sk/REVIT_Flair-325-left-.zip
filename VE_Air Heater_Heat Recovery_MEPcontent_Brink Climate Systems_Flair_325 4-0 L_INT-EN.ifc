Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2018-07-03T16:41:49
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160720_1515(x64) - Exporter 17.0.501.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jul 03 16:41:49 2018 * Host: B3ROBRAWR2791 * Database: C:\Users\CS\AppData\Local\Temp\{0295D7D5-C20E-4380-93F1-EBD7D03039A8}\ifc * Database version: 5507 * Database creation date: Tue Jul 03 16:41:48 2018 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Tue Jul 03 16:41:48 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jul 03 16:41:48 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcAirToAirHeatRecovery: 325 4-0 L, VE_Air Heater_Heat Recovery_MEPcontent_Brink Climate Systems_Flair_325_Left_INT-EN:325 4-0 L:1293611
In: V00
Type - Material: Color RGB 241-240-234, Color RGB 152-158-161
Type - Dimensions - Connection Diameter: 160 mm; Depth: 560 mm; Diameter: 32 mm; Height: 650 mm; Width: 750 mm
Type - Electrical - Loads - Nominal Voltage: 230 V
Type - Identity Data - Article Description: Heat recovery unit; Article Type: 325 4-0 L; Base Family Version: 11.17; Content Supplier URL: www.MEPcontent.com; Copyright: © Stabiplan International BV; Custom: no; Description: Heat recovery unit; EMCS Version: 4.0; ETIM Article Class: EC011285; Family Version: 11.17; GTIN: 8718391196272; Manufacturer: Brink Climate Systems; Manufacturer Art. No.: 430000; Manufacturer URL: https://www.brinkclimatesystems.nl/downloads_flair-325; MEPcontent Class: AIR_HEATER_HEAT_RECOVERY; Model: 325 4-0 L; OmniClass Number: 23.75.70.17; OmniClass Title: Water Heated and Cooled Terminal Heating and Cooling Units; Product Line: Brink Climate Systems; Revit Version: 2017; Type Name: 325 4-0 L; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Materials and Finishes - Color Body: Color RGB 241-240-234; Color Door: Color RGB 152-158-161; Glass: Color RGB 218-227-224
Type - Other - Category: Mechanical Equipment; Connection Inner Radius: 77 mm; Connection Radius: 79 mm; Family Name: VE_Air Heater_Heat Recovery_MEPcontent_Brink Climate Systems_Flair_325_Left_INT-EN; Flange Radius: 90 mm
Pset_ManufacturerTypeInformation - Manufacturer: Brink Climate Systems
Constraints - Offset: 0 mm
Dimensions - Area: 3.34031 m2; Volume: 0.565045 m3
Electrical - Loads - Nominal Current: 0 V; Power: 0 W
Identity Data - Design Option: Main Model; Mark: 4
Mechanical - Drain Fixture Units: 0; Heating Power: 0; System Classification: Sanitary,Power,Supply Air,Return Air,Exhaust Air,Supply Air
Mechanical - Flow - Exhaust Air Flow: 0 m3/s; Return Air Flow: 0 m3/s; Supply Air Flow 1: 0 m3/s; Supply Air Flow 2: 0 m3/s
Other - Family: VE_Air Heater_Heat Recovery_MEPcontent_Brink Climate Systems_Flair_325_Left_INT-EN: 325 4-0 L; Family and Type: VE_Air Heater_Heat Recovery_MEPcontent_Brink Climate Systems_Flair_325_Left_INT-EN: 325 4-0 L; Type: VE_Air Heater_Heat Recovery_MEPcontent_Brink Climate Systems_Flair_325_Left_INT-EN: 325 4-0 L; Type Id: VE_Air Heater_Heat Recovery_MEPcontent_Brink Climate Systems_Flair_325_Left_INT-EN: 325 4-0 L; Wall Offset: 8 mm
Phasing - Phase Created: 4. Plan over 10 years
Visibility - Mounting Bracket: yes; Service Area: no
